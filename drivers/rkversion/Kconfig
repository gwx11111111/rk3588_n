## drivers/rkversion/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0
config ROCKCHIP_RKVERSION
	tristate
	default y
```
